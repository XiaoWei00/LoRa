# IAR project basicRF.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\Cpus\stm8sxxx; ..\..\Cpus\stm8sxxx\clk; ..\..\Cpus\stm8sxxx\i2c; ..\..\Cpus\stm8sxxx\spi; ..\..\Cpus\stm8sxxx\timer; ..\..\Cpus\stm8sxxx\uart; ..\..\Cpus\stm8sxxx\exti; ..\..\Cpus\stm8sxxx\rf; ..\..\Devs\sx1276; ..\..\Net\Mac; ..\..\Net\Nwk; ..\..\Net\Hal; ..\..\OS; ..\..\Platforms\GBlora; ..\..\Platforms\GBlora\key; ..\..\Platforms\GBlora\led; ..\..\Platforms\GBlora\s_i2c; ..\..\Platforms\GBlora\s_spi; 
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: basicRF.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    ./: basicRF.c
  group Cpu
    ../../Cpus/stm8sxxx/clk/: clk.c
    ../../Cpus/stm8sxxx/exti/: exti.c
    ../../Cpus/stm8sxxx/rf/: rf.c
    ../../Cpus/stm8sxxx/timer/: timer.c
    ../../Cpus/stm8sxxx/: types.h
    ../../Cpus/stm8sxxx/uart/: uart.c
  group Dev
    ../../Devs/sx1276/: sx1276.c
  group Net/Hal
    ../../Net/Hal/: hal.c
  group Net/Mac
    ../../Net/Mac/: csma.c mac.c
  group Net/Nwk
    ../../Net/Nwk/: nwk.c nwk.h
  group OS
    ../../OS/: IotOS.c
    ../../OS/Main/: main.c
  group Platform
    ../../Platforms/GBlora/led/: led.c
    ../../Platforms/GBlora/s_spi/: s_spi.c
