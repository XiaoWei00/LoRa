<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\basicRF.c</name>
    </file>
  </group>
  <group>
    <name>Cpu</name>
    <file>
      <name>$PROJ_DIR$\..\..\Cpus\stm8sxxx\clk\clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Cpus\stm8sxxx\exti\exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Cpus\stm8sxxx\rf\rf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Cpus\stm8sxxx\timer\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Cpus\stm8sxxx\types.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Cpus\stm8sxxx\uart\uart.c</name>
    </file>
  </group>
  <group>
    <name>Dev</name>
    <file>
      <name>$PROJ_DIR$\..\..\Devs\sx1276\sx1276.c</name>
    </file>
  </group>
  <group>
    <name>Net</name>
    <group>
      <name>Hal</name>
      <file>
        <name>$PROJ_DIR$\..\..\Net\Hal\hal.c</name>
      </file>
    </group>
    <group>
      <name>Mac</name>
      <file>
        <name>$PROJ_DIR$\..\..\Net\Mac\csma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Net\Mac\mac.c</name>
      </file>
    </group>
    <group>
      <name>Nwk</name>
      <file>
        <name>$PROJ_DIR$\..\..\Net\Nwk\nwk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Net\Nwk\nwk.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>OS</name>
    <file>
      <name>$PROJ_DIR$\..\..\OS\IotOS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\OS\Main\main.c</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <file>
      <name>$PROJ_DIR$\..\..\Platforms\GBlora\led\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Platforms\GBlora\s_spi\s_spi.c</name>
    </file>
  </group>
</project>


